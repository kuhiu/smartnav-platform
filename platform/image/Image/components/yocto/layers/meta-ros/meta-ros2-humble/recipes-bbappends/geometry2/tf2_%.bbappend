# Copyright (c) 2020 LG Electronics, Inc.
# Copyright (c) 2022 Acceleration Robotics S.L. <contact@accelerationrobotics.com>

DEPENDS += " \ 
    rosidl-cmake \
    rosidl-adapter \
"

ROS_BUILD_DEPENDS += " \
    python3-numpy-native \
"