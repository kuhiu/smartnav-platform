SRC_URI += "file://user_2023-02-06-00-38-00.cfg \
            file://user_2023-02-06-00-42-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

