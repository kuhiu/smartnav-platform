FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
file://system-user.dtsi \
file://0001_clk_patch.patch \
"
