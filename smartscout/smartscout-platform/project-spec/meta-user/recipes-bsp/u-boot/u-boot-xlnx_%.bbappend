FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://platform-top.h \
            file://user_2023-05-23-21-27-00.cfg \
            file://user_2023-05-23-23-50-00.cfg \
            "
