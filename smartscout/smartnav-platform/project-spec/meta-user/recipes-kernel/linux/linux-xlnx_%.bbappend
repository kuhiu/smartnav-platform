SRC_URI += "file://user_2023-01-07-17-51-00.cfg \
            file://user_2023-01-07-18-03-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

